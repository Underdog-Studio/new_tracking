# Keil uVision project Project.uvprojx, settings and files
target GD32E230C_START (6100001::V6.10.1::.\ARMCLANG)
  device: GD32E230G6 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x0001800) IROM(0x08000000,0x0008000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32E230C_START +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\CMSIS\Include;..\GD32E23x_standard_peripheral\Include;..\USER;..\Hardware_Abstraction_Layer;..\Device_Drive_Layer;..\Software_Layer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ./: gd32e23x_it.c main.c
  group CMSIS
    ../CMSIS/Source/: system_gd32e23x.c
  group GD32E23x_Peripherals
    ../GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Startup
    ../Startup/: startup_gd32e23x.s
  group Hardware_Abstraction_Layer
    ../Hardware_Abstraction_Layer/: Configuration_hal.c spi_hal.c adc_hal.c EXTI_hal.c flash_hal.c I2C_hal.c gpio_hal.c
  group Device_Drive_Layer
    ../Device_Drive_Layer/: Infrared_Probe_drv.c Button_drv.c LED_drv.c EEPROM_drv.c
  group Software_Layer
    ../Software_Layer/: System_time.c Software_Register.c
software components: CMSIS:CORE 5.1.2
